# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\W25Q64;..\HARDWARE\ADC;..\HARDWARE\SERVO;..\HARDWARE\MOTOR;..\Libraries\CMSIS;..\Libraries\CMSIS\Include;..\Libraries\FWlib\inc;..\LiteOS\arch\arm\arm-m\cortex-m3;..\LiteOS\arch\arm\arm-m\include;..\LiteOS\cmsis\1.0;..\LiteOS\cmsis\2.0;..\LiteOS\cmsis;..\LiteOS\kernel\include;..\LiteOS\kernel\base\include;..\LiteOS\kernel\extended\include;..\LiteOS\OS_CONFIG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/W25Q64/: MySPI.c W25Q64.c limit_storage.c
    ../HARDWARE/ADC/: AD.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/MOTOR/: motor.c
  group README
    ../: README.TXT
  group STM32FWLib
    ../Libraries/FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c misc.c stm32f10x_adc.c stm32f10x_tim.c
  group LiteOS/cmsis
    ../LiteOS/cmsis/: cmsis_liteos.c system_stm32f1xx.c
  group LiteOS/arch
    ../LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group LiteOS/kernel
    ../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memcheck.c los_membox.c los_memory.c
    ../LiteOS/kernel/base/mem/common/: los_memstat.c los_slab.c los_slabmem.c
    ../LiteOS/kernel/base/misc/: los_misc.c
    ../LiteOS/kernel/base/om/: los_err.c
    ../LiteOS/kernel/extended/tickless/: los_tickless.c
    ../LiteOS/kernel/: los_init.c
  group LiteOS/config
    ../LiteOS/OS_CONFIG/: target_config.h
